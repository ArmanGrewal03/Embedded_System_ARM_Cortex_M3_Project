# Keil uVision project Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: LPC1768 NXP
  pack: Keil.LPC1700_DFP.2.7.2
  cpu: IRAM(0x10000000,0x8000) IRAM2(0x2007C000,0x8000) IROM(0x00000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Bitband
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x9000
  memory RVCT10: RAM 0x2007c000 size 0x9000
  group Source Group 1
    ./: KBD.c GLCD_SPI_LPC1700.c Font_6x8_h.h Font_16x24_h.h KBD.h GLCD.h main.c menu.c player.c player.h gallery.c gallery.h flappy.h flappy.c
    ../../../718_project/Project/: menu.h
  group Resources
    ./: cat.h tree.h
  group New Group
    ./: type.h usb.h usbaudio.h usbcfg.h usbcore.c usbcore.h usbdesc.c usbdesc.h usbhw.c usbhw.h usbreg.h usbuser.c usbuser.h adcuser.c adcuser.h audio.h
software components: CMSIS:CORE 5.3.0, Compiler:Event Recorder 1.5.1, Board Support:A/D Converter 1.0.0, Board Support:LED 1.0.0, Device:GPIO 1.1.0, Device:PIN 1.0.0, Device:Startup 1.0.0
